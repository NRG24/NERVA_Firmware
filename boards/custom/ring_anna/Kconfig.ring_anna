## boards/custom/ring_anna/board.yml
```yaml
board:
  name: ring_anna
  full_name: Ring board (u-blox ANNA-B402 / nRF52833)
  vendor: custom
  socs:
    - name: nrf52833
```
